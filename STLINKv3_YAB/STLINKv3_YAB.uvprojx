# Keil uVision project STLINKv3_YAB.uvprojx, settings and files
target STLINKv3_YAB (6120000::V6.12::.\ARMCLANG)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20010000,0x30000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STLINKv3_YAB +hex
  AfterMake: fromelf --bin !L --output .\Build\STLINKv3_YAB.bin
  AfterMake: .\Build\encrypt_to_f3_files.bat
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: C:\Keil\ARM\PACK\ARM\CMSIS\5.6.0\CMSIS\Include;C:\Keil\ARM\PACK\ARM\CMSIS\5.6.0\CMSIS\Driver\Include;.\USER;.\Utility
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT6: RAM 0x20010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\USER\STLINKv3_YAB.sct
  link misc: --pad=0xFF
  group USER
    ./USER/: main.c STLINK_V3MINI_BSP.c USBD_User_CDC_ACM_UART_0.c USBD_User_MSC_0.c USBD_User_MSC_Init.c
  group Utility
    ./Utility/: crc32.c Flash.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, File System:CORE 6.13.8, File System:Drive:RAM 6.13.8, USB:CORE 6.14.1, USB:Device 6.14.1, USB:Device:CDC 6.14.1, USB:Device:MSC 6.14.1, CMSIS Driver:USART 1.13.0, CMSIS Driver:USB Device:High-speed 1.14.0, Device:STM32Cube Framework:Classic 1.2.7, Device:STM32Cube HAL:Common 1.2.7, Device:STM32Cube HAL:Cortex 1.2.7, Device:STM32Cube HAL:DMA 1.2.7, Device:STM32Cube HAL:Flash 1.2.7, Device:STM32Cube HAL:GPIO 1.2.7, Device:STM32Cube HAL:PCD 1.2.7, Device:STM32Cube HAL:PWR 1.2.7, Device:STM32Cube HAL:RCC 1.2.7, Device:STM32Cube HAL:UART 1.2.7, Device:Startup 1.2.4
